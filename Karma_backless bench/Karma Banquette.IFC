Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Karma Banquette.IFC
Time: 2020-07-01T07:35:31
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: KARM-BANQ-004_Default (2)
In: Default Storey
Material: Douka

# IfcBeam: KARM-BANQ-005_Default
In: Default Storey
Material: S 235

# IfcBeam: KARM-BANQ-008_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: KARM-BANQ-002-PCE
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 56.868; Area Measure: 3.28584; Volume Measure: 0.0260918

# IfcBuildingElementProxy: KARM-BANQ-003_Default (3)
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-BANQ-008_Default
In: Default Storey
Material: S 235
